Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-11-08T18:41:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 08 18:41:21 2023 * Host: ZIL5CD2317NJM * Database: C:\Users\MKhan\AppData\Local\Temp\0069bd8b-86d4-44ac-92b2-75af6f8699f7\f9648de5-f58a-4dbe-a862-f4eb878d438a\ifc * Database version: 5507 * Database creation date: Wed Nov 08 18:41:20 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 08 18:41:20 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 08 18:41:20 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:1/4" Head, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: CRAFADA1923A55R-J_Just_Sink_Drop-In:CRAFADA1923A55R-J, CRAFADA1923A55R-J_Just_Sink_Drop-In:CRAFADA1923A55R-J:811798
In: Level 1
Type - Material: 304 Stainless Steel, Stainless Steel
Type - Pset_DistributionFlowElementCommon - Reference: CRAFADA1923A55R-J
Type - Pset_ElectricalDeviceCommon - IP_Code: n/a; InsulationStandardClass: n/a
Type - Pset_ElementShading - Color: 304 Stainless Steel
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Name: Sink_CRAFADA1923A55R-J; Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: CRAFADA1923A55R-J
Material: Stainless Steel
Pset_DistributionFlowElementCommon - sets with these values: 2
